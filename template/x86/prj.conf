## prj.conf
```kconfig
CONFIG_ARC_INIT=y
```

## src/main.c
```c
#include <zephyr.h>

void main (void)
{

}
```
